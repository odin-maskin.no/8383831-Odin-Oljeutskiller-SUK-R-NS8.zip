Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: F:\\BRICSCAD\\Oljeutskillere\\_BIM filer\\SUK-R\\8383831 Odin Oljeutskiller SUK-R NS8.ifc
Time: 2023-03-01T14:38:50
Author: Undefined
Organization: Undefined
Written by: BricsCAD BIM 23.1.08
Made in: BricsCAD BIM 23.1.08
Authorization: Undefined

# IfcSite, Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuilding, Site
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm
